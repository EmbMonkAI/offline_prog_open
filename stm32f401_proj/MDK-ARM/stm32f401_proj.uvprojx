# Keil uVision project stm32f401_proj.uvprojx, settings and files
target stm32f401_proj (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401RBTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x801FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: stm32f401_proj +hex
  c flags: OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xC,GEN_LOG_PORT_UART
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../../app;../../bsp;../../modules/device/led;../../modules/device/buzzer;../../modules/component/gen_log;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;../../modules/device/button;../../dap;../../dap/DAP;../../dap/algo;../../target;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../../modules/device/lcd;../../modules/device/font;../../modules/component/font_mgr;../../modules/service/display;../../modules/service/display/test;../../modules/app/ui;../../modules/app/font_config
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_mmc.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Application/User/app
    ../../app/: app_util.c app_count.c app_sec.c app_main.c app_flash.c app_rdp.c app_usb.c app_ui.c
  group Application/User/bsp
    ../../bsp/: bsp_gpio.c bsp_buzzer.c bsp_uart.c
  group modules/device/led
    ../../modules/device/led/: dev_led.c
  group modules/device/buzzer
    ../../modules/device/buzzer/: dev_buzzer.c
  group modules/device/button
    ../../modules/device/button/: dev_button.c
  group modules/device/lcd_tft
    ../../modules/device/lcd/: dev_lcd_tft.c st7789_tft.c
    ../../modules/device/font/: dev_font.c
  group modules/component/font_mgr
    ../../modules/component/font_mgr/: font_mgr.c
  group modules/service/display_tft
    ../../modules/service/display/: svc_display_tft.c
    ../../modules/service/display/test/: test_tft.c
    ../../modules/app/ui/: ui_view_files.c ui_view_params.c ui_view_program.c
  group dap
    ../../dap/DAP/: DAP.c SW_DP.c JTAG_DP.c SWO.c
    ../../dap/: SWD_host.c error.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c fatfs_platform.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group target
    ../../target/: transport_swd.c target_program.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.3.0
